# Keil uVision project PWM.uvprojx, settings and files
target PWM (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PWM +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\SYSTEM\timer;..\SYSTEM\adc;..\HARDWARE\DHT11;..\HARDWARE\DS18B20;..\HARDWARE\BEEP;..\HARDWARE\RELAY;..\HARDWARE\SERVO;..\HARDWARE\WATER_SENSOR;..\HARDWARE\HC_SR04;..\HARDWARE\RC522;..\SYSTEM\iic;..\HARDWARE\OLED;..\HARDWARE\GY906;..\HARDWARE\MAX30102;..\HARDWARE\AS608;..\NET;..\HARDWARE\MQTT;..\HARDWARE\GP2Y;.\menu;..\HARDWARE\STEP_MOTOR;..\HARDWARE\SGP30;..\HARDWARE\MatrixKeys;..\SYSTEM\rtc;..\HARDWARE\STMFLASH
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
    ./menu/: menu.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/MatrixKeys/: matrixkeys.c
    ../HARDWARE/SERVO/: servo.c
    ../HARDWARE/RC522/: rc522.c
    ../HARDWARE/OLED/: bsp_oled_iic.c
    ../HARDWARE/STMFLASH/: MyFLASH.c Store.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c usart3.c
    ../SYSTEM/timer/: timer1.c timer2.c
    ../SYSTEM/iic/: iic.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_exti.c stm32f10x_rtc.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_flash.c
